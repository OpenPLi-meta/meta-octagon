KV = "4.4.176"
SRCDATE = "20230213"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "4eff16d93d10dbc57f3b93c2c67a8e84"
SRC_URI[sha256sum] = "af41b243569c12e9d3e742e70ad0c3dc1f0491c755b800aeb57a4133b864a014"
