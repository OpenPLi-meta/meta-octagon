KV = "4.4.176"
SRCDATE = "20221122"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "16d62ce4cfa72882afcf5202b2bb315a"
SRC_URI[sha256sum] = "53605d42f70650da7d600ab9ee51f0115cb1158f90006bb2e81c612ace7ced51"
